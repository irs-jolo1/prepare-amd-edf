SUMMARY = "Python package for pylibiio"
HOMEPAGE = ""
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://${COMMON_LICENSE_DIR}/MIT;md5=0835ade698e0bcf8506ecda2f7b4f302"

SRC_URI[sha256sum] = "f2615ab20093ec8ca87417f1e38dfdca1baa21a719328f4b27d28c99b1d23eb5"

inherit pypi python_setuptools_build_meta
