# Auto-Generated by cargo-bitbake 0.3.16-alpha.0
#
inherit cargo

# If this is git based prefer versioned ones if they exist
# DEFAULT_PREFERENCE = "-1"

# how to get stream-server-rs could be as easy as but default to a git checkout:
# SRC_URI += "crate://crates.io/stream-server-rs/0.1.0"
SRC_URI += "git://git@github.com/irs-jolo1/prepare-amd-edf.git;protocol=ssh;nobranch=1"
# SRCREV was only meaningful for the git:// SRC_URI above, which is removed
# in stream-server-rs.inc (no SSH access in the fetcher environment). With
# no SCM fetcher left in SRC_URI, leaving a real SRCREV set makes
# do_packagedata (and other SCM-version-aware tasks) fail with "SRCREV was
# used yet no valid SCM was found in SRC_URI".
SRCREV = "INVALID"
S = "${WORKDIR}/git"
CARGO_SRC_DIR = ""

PV:append = ".rev0d582b4ea3"

# please note if you have entries that do not begin with crate://
# you must change them to how that package can be fetched
SRC_URI += " \
    crate://crates.io/aho-corasick/1.1.4 \
    crate://crates.io/async-trait/0.1.89 \
    crate://crates.io/atomic-waker/1.1.2 \
    crate://crates.io/axum-core/0.4.5 \
    crate://crates.io/axum/0.7.9 \
    crate://crates.io/base64/0.22.1 \
    crate://crates.io/bitflags/2.11.1 \
    crate://crates.io/block-buffer/0.10.4 \
    crate://crates.io/byteorder/1.5.0 \
    crate://crates.io/bytes/1.11.1 \
    crate://crates.io/cfg-if/1.0.4 \
    crate://crates.io/cfg_aliases/0.2.1 \
    crate://crates.io/cpufeatures/0.2.17 \
    crate://crates.io/crypto-common/0.1.7 \
    crate://crates.io/data-encoding/2.11.0 \
    crate://crates.io/digest/0.10.7 \
    crate://crates.io/errno/0.3.14 \
    crate://crates.io/form_urlencoded/1.2.2 \
    crate://crates.io/futures-channel/0.3.32 \
    crate://crates.io/futures-core/0.3.32 \
    crate://crates.io/futures-macro/0.3.32 \
    crate://crates.io/futures-sink/0.3.32 \
    crate://crates.io/futures-task/0.3.32 \
    crate://crates.io/futures-util/0.3.32 \
    crate://crates.io/generic-array/0.14.7 \
    crate://crates.io/getrandom/0.2.17 \
    crate://crates.io/http-body-util/0.1.3 \
    crate://crates.io/http-body/1.0.1 \
    crate://crates.io/http/1.4.0 \
    crate://crates.io/httparse/1.10.1 \
    crate://crates.io/httpdate/1.0.3 \
    crate://crates.io/hyper-util/0.1.20 \
    crate://crates.io/hyper/1.9.0 \
    crate://crates.io/industrial-io/0.6.1 \
    crate://crates.io/itoa/1.0.18 \
    crate://crates.io/lazy_static/1.5.0 \
    crate://crates.io/libc/0.2.186 \
    crate://crates.io/libiio-sys/0.4.1 \
    crate://crates.io/lock_api/0.4.14 \
    crate://crates.io/log/0.4.29 \
    crate://crates.io/matchers/0.2.0 \
    crate://crates.io/matchit/0.7.3 \
    crate://crates.io/memchr/2.8.0 \
    crate://crates.io/mime/0.3.17 \
    crate://crates.io/mio/1.2.0 \
    crate://crates.io/nix/0.29.0 \
    crate://crates.io/nu-ansi-term/0.50.3 \
    crate://crates.io/once_cell/1.21.4 \
    crate://crates.io/parking_lot/0.12.5 \
    crate://crates.io/parking_lot_core/0.9.12 \
    crate://crates.io/percent-encoding/2.3.2 \
    crate://crates.io/pin-project-lite/0.2.17 \
    crate://crates.io/ppv-lite86/0.2.21 \
    crate://crates.io/proc-macro2/1.0.106 \
    crate://crates.io/quote/1.0.45 \
    crate://crates.io/rand/0.8.6 \
    crate://crates.io/rand_chacha/0.3.1 \
    crate://crates.io/rand_core/0.6.4 \
    crate://crates.io/redox_syscall/0.5.18 \
    crate://crates.io/regex-automata/0.4.14 \
    crate://crates.io/regex-syntax/0.8.10 \
    crate://crates.io/rustversion/1.0.22 \
    crate://crates.io/ryu/1.0.23 \
    crate://crates.io/scopeguard/1.2.0 \
    crate://crates.io/serde/1.0.228 \
    crate://crates.io/serde_core/1.0.228 \
    crate://crates.io/serde_derive/1.0.228 \
    crate://crates.io/serde_json/1.0.149 \
    crate://crates.io/serde_path_to_error/0.1.20 \
    crate://crates.io/serde_urlencoded/0.7.1 \
    crate://crates.io/sha1/0.10.6 \
    crate://crates.io/sharded-slab/0.1.7 \
    crate://crates.io/signal-hook-registry/1.4.8 \
    crate://crates.io/slab/0.4.12 \
    crate://crates.io/smallvec/1.15.1 \
    crate://crates.io/socket2/0.6.3 \
    crate://crates.io/syn/2.0.117 \
    crate://crates.io/sync_wrapper/1.0.2 \
    crate://crates.io/thiserror-impl/1.0.69 \
    crate://crates.io/thiserror-impl/2.0.18 \
    crate://crates.io/thiserror/1.0.69 \
    crate://crates.io/thiserror/2.0.18 \
    crate://crates.io/thread_local/1.1.9 \
    crate://crates.io/tokio-macros/2.7.0 \
    crate://crates.io/tokio-tungstenite/0.24.0 \
    crate://crates.io/tokio/1.52.2 \
    crate://crates.io/tower-http/0.5.2 \
    crate://crates.io/tower-layer/0.3.3 \
    crate://crates.io/tower-service/0.3.3 \
    crate://crates.io/tower/0.5.3 \
    crate://crates.io/tracing-attributes/0.1.31 \
    crate://crates.io/tracing-core/0.1.36 \
    crate://crates.io/tracing-log/0.2.0 \
    crate://crates.io/tracing-subscriber/0.3.23 \
    crate://crates.io/tracing/0.1.44 \
    crate://crates.io/tungstenite/0.24.0 \
    crate://crates.io/typenum/1.20.0 \
    crate://crates.io/unicode-ident/1.0.24 \
    crate://crates.io/utf-8/0.7.6 \
    crate://crates.io/valuable/0.1.1 \
    crate://crates.io/version_check/0.9.5 \
    crate://crates.io/wasi/0.11.1+wasi-snapshot-preview1 \
    crate://crates.io/windows-link/0.2.1 \
    crate://crates.io/windows-sys/0.61.2 \
    crate://crates.io/zerocopy-derive/0.8.48 \
    crate://crates.io/zerocopy/0.8.48 \
    crate://crates.io/zmij/1.0.21 \
"



# FIXME: update generateme with the real MD5 of the license file
LIC_FILES_CHKSUM = " \
    file://MIT;md5=generateme \
"

SUMMARY = "IIO streaming server"
HOMEPAGE = ""
LICENSE = "MIT"

# includes this file if it exists but does not fail
# this is useful for anything you may want to override from
# what cargo-bitbake generates.
include stream-server-rs-${PV}.inc
include stream-server-rs.inc
