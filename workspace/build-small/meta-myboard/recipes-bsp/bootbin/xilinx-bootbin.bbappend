
BIF_COMMON_ATTR[pskfile] = "./psk0.pem"
